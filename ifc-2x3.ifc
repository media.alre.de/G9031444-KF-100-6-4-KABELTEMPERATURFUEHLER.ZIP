Properties of the parts of a building model (IFC2X3)

# File
Description: Kabel-Temperaturfühler, PT 100, 6 m, Fühlerleitung Silikon, -50…+180 °C, 4-Leiter, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9031444, Kabel-Temperaturfühler, PT 100, 6 m, Fühlerleitung Silikon, -50…+180 °C, 4-Leiter
In: Raum
Description: Zur Temperaturmessung von flüssigen Medien mittels Einbau in Tauchhülsen (TH/NTH). Zur Temperaturmessung von Luft und nicht aggressiven Gasen im Luftkanal mittels Einbau in eine Schutzwendel (SW-200).; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9031444; ModelLabel: KF-100/6-4; GlobalTradeItemNumber: 4050528072986; ProductURL: https://alre.de/produkt_G9031444
Pset_Specification - NominalLength: 6 m; NominalWidth: 0.006 m; NominalDepth: 0.006 m; NetWeight: 0.105
Pset_ALRE_ETIM_Properties - Kabellänge: 6; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -50; Explosionsgeschützt: no; Schutzart (IP): IP67; Einsatzgebiet: Tauchrohr/-kanal; Temperaturmessbereich: -50; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensortyp: Pt100; Gehäusehöhe: 6; Gehäusebreite: 6; Gehäusetiefe: 6000; Geeignet für Kanalbefestigung: yes; Festes Kabel am Sensor: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9031444.pdf
